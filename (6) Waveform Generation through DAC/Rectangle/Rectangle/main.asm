.INCLUDE "M32DEF.INC"

.ORG 0x0000

START:
    LDI R16, HIGH(RAMEND)
    OUT SPH, R16
    LDI R16, LOW(RAMEND)
    OUT SPL, R16

    LDI R16, 0xFF
    OUT DDRC, R16

MAIN_LOOP:
    LDI R16, 0xFF
    OUT PORTC, R16
    CALL DELAY

    LDI R16, 0x00
    OUT PORTC, R16
    CALL DELAY

    RJMP MAIN_LOOP

DELAY:
    LDI R18, 0xFF
DELAY_LOOP1:
    LDI R19, 0xFF
DELAY_LOOP2:
    DEC R19
    BRNE DELAY_LOOP2
    DEC R18
    BRNE DELAY_LOOP1
    RET
